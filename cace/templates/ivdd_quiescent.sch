** sch_path: cace/templates/ivdd_quiescent.sch
**.subckt ivdd_quiescent
x1 net1 vout ibias vin vin GND dvdd GND dvdd sky130_td_ip__opamp_hp
V_AVDD avdd GND CACE{Vvdd}
.save i(v_avdd)
V_DVDD dvdd GND 1.8
.save i(v_dvdd)
I_IBIAS avdd ibias 100n
V_VOUTCM vout_cm GND 1.65
.save i(v_voutcm)
V1 net1 avdd 0
VCM vin GND CACE{Vcm}
.save i(vcm)
**** begin user architecture code


.control
save all
alter VCM pwl = [ 0 0 10 3.3 ]
alter VCM dc = 0
tran 10m 10
run
let i_avdd = -1 * i(V1)
meas tran max_iavdd MAX i_avdd

echo Max current from AVDD (no load): $&max_iavdd

echo $&max_iavdd > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the power supply rejection ratio of the amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]





**** end user architecture code
**.ends
.GLOBAL GND
.end
