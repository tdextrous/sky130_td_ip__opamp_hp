** sch_path: cace/templates/ivdd_disabled.sch
**.subckt ivdd_disabled
x1 net1 vout ibias vout vin GND dvdd GND GND sky130_td_ip__opamp_hp
V_AVDD avdd GND CACE{Vvdd}
.save i(v_avdd)
V_DVDD dvdd GND 1.8
.save i(v_dvdd)
I_IBIAS avdd ibias 100n
R1 vout vout_cm 5k m=1
C1 vout vout_cm 30p m=1
V_VOUTCM vout_cm GND 1.65
.save i(v_voutcm)
E1 vin GND VOL=' 0*cos(2*PI*10K*time)+CACE{Vcm} '
V1 avdd net1 0
.save i(v1)
**** begin user architecture code


.control
save all

tran 100n 10u
run

let i_avdd = i(V1)
meas tran max_iavdd MAX i_avdd

echo Max current (disabled): $&max_iavdd

echo $&max_iavdd > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc




* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the power supply rejection ratio of the amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]


**** end user architecture code
**.ends
.GLOBAL GND
.end
