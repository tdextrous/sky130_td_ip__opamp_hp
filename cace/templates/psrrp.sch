** sch_path: cace/templates/psrrp.sch
**.subckt psrrp
x1 net1 vout_avdd ibias GND GND GND dvdd GND dvdd sky130_td_ip__opamp_hp
V_AVDD avdd GND CACE{Vvdd}
.save i(v_avdd)
V_DVDD dvdd GND 1.8
.save i(v_dvdd)
I_IBIAS avdd ibias 100n
R1 vout_avdd vout_cm 5k m=1
C1 vout_avdd vout_cm 30p m=1
V_VOUTCM vout_cm GND 1.65
.save i(v_voutcm)
V1 net1 avdd ac 1
x2 avdd vout_av ibias vinn_dm vinp_dm GND dvdd GND dvdd sky130_td_ip__opamp_hp
R2 vout_av vout_cm 5k m=1
C2 vout_av vout_cm 30p m=1
VDM vinn_dm vinp_dm 19u ac 1
VCM vinp_dm GND CACE{Vcm}
.save i(vcm)
**** begin user architecture code


.control
save all

* Calculate input offset voltage
alter VDM pwl = [ 0 -10m 10 10m ]
tran 10m 10
run
let vid = v(vinn_dm) - v(vinp_dm)
let vout = v(vout_av)
meas tran input_offset_voltage FIND vid WHEN vout=1.65

alter @VDM[pwl] = [ 0 0 ]
alter VDM dc = $&input_offset_voltage
alter VDM ac = 1

* Run AC sweep from 1Hz to 1GHz
AC DEC 100 1 1000000000
run

* Get DC gain in DBs.
let av_db = db(vout_av)
let avdd_db = db(vout_avdd)
let psrrp_db = av_db - avdd_db

meas AC psrrp_dc FIND psrrp_db AT=1
meas AC psrrp_10k FIND psrrp_db AT=10K

echo
echo ===================================
echo PSRR+ characterization results:
echo - PSRR @ 1 Hz: $&psrrp_dc
echo - PSRR @ 10 kHz: $&psrrp_10k
echo ===================================

echo $&psrrp_dc $&psrrp_10k > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc




* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the power supply rejection ratio of the amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]


**** end user architecture code
**.ends
.GLOBAL GND
.end
