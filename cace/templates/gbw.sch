** sch_path: cace/templates/gbw.sch
**.subckt gbw
x1 avdd vout ibias vinn vinp GND dvdd GND dvdd sky130_td_ip__opamp_hp
V_AVDD avdd GND CACE{Vvdd}
.save i(v_avdd)
V_DVDD dvdd GND 1.8
.save i(v_dvdd)
I_IBIAS avdd ibias 100n
VCM net1 GND CACE{Vcm}
R1 vout vout_cm 5k m=1
C1 vout vout_cm 30p m=1
V_VOUTCM vout_cm GND 1.65
.save i(v_voutcm)
E1 vinn net1 vid GND -0.5
VDM vid GND -1.7244m ac 1
E2 vinp net1 vid GND 0.5
**** begin user architecture code


.control
save all

* Calculate input offset voltage
alter @VDM[pwl] = [ 0 -10m 10 10m ]
tran 1m 10
run
let vid = v(vid)
let vout = v(vout)
meas tran input_offset_voltage FIND vid WHEN vout=1.65 RISE=LAST


alter @VDM[pwl] = [ 0 0 ]
alter VDM dc = $&input_offset_voltage
alter VDM ac = 1

* Run AC sweep from 1Hz to 1GHz
AC DEC 100 1 1000000000
run

* Get DC gain in DBs.
let av_db = db(vout / vid)
let av_lin = mag(vout / vid)
let ol_phase = 180/PI*phase(vout / vid)

meas AC av0_db FIND av_db AT=1
meas AC av0_lin FIND av_lin AT=1
let av0_minus_3 = av0_db - 3
meas AC fp1 WHEN av_db=av0_minus_3
meas AC ugf WHEN av_db=0
meas AC ol_phase_at_ugf FIND ol_phase AT=ugf

let pm = 180 + ol_phase_at_ugf
let gbw = av0_lin * fp1

echo
echo ===================================
echo Open-Loop characterization results:
echo - DC Gain: $&av0_db
echo - 3-dB frequency: $&fp1
echo - GBW: $&gbw
echo - PM: $&pm
echo ===================================

echo $&av0_db $&gbw $&pm > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc




* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the power supply rejection ratio of the amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1
.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]


**** end user architecture code
**.ends
.GLOBAL GND
.end
