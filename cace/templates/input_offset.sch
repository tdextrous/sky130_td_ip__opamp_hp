** sch_path: cace/templates/input_offset.sch
**.subckt input_offset
x1 avdd vout ibias vinn vinp GND dvdd GND dvdd sky130_td_ip__opamp_hp
V_AVDD avdd GND CACE{Vvdd}
.save i(v_avdd)
V_DVDD dvdd GND 1.8
.save i(v_dvdd)
I_IBIAS avdd ibias 100n
VCM net1 GND CACE{Vcm}
R1 vout vout_cm 5k m=1
C1 vout vout_cm 30p m=1
V_VOUTCM vout_cm GND 1.65
.save i(v_voutcm)
E1 vinn net1 vid GND -0.5
VDM vid GND 0 ac 1
E2 vinp net1 vid GND 0.5
**** begin user architecture code


.save all

.control
save all
alter @VDM[pwl] = [ 0 -10m 10 10m ]
tran 1m 10
run
let vid = v(vid)
let vout = v(vout)
meas tran input_offset_voltage FIND vid WHEN vout=1.65 RISE=LAST

echo
echo ===================================
echo Differential-mode DC sweep results
echo - Input Offset voltage: $&input_offset_voltage
echo ===================================

echo $&input_offset_voltage > CACE{simpath}/CACE{filename}_CACE{N}.data

*plot vout

quit

.endc




* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the power supply rejection ratio of the amplifier

.include CACE{DUT_path}

.lib CACE{PDK_ROOT}/CACE{PDK}/libs.tech/combined/sky130.lib.spice CACE{corner}

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
